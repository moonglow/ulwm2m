# IAR project iar_arm_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: WITH_DTLS
  ICCARM.IExtraOptions: --vla
  ICCARM.CCIncludePath2: libulwm2m; dtls; dtls/tinydtls; example
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iar_arm_project.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group dtls
    dtls/tinydtls/: dtls-ccm.c dtls-crypto.c dtls-hmac.c dtls-log.c dtls-peer.c dtls.c netq.c
    dtls/: dtls-support.c
    dtls/tinydtls/ecc/: ecc.c
    dtls/lib/: memb.c
    dtls/tinydtls/aes/: rijndael.c
    dtls/tinydtls/sha2/: sha2.c
  group example
    example/: main.c object_3300.c object_3300.h object_3303.c object_3303.h object_3341.c object_3341.h udp.c udp.h
  group libulwm2m
    libulwm2m/: coap.c lwm2m.c object_device.c object_security.c object_server.c tlv.c utils.c
